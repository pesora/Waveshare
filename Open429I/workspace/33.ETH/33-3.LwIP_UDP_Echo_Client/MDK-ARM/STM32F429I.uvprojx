# Keil uVision project STM32F429I.uvprojx, settings and files
target STM32F429I Configuration (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;                               ../Drivers/STM32F4xx_HAL_Driver/Inc;                               ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                               ../Drivers/CMSIS/Include;                               ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                               ..\BSP;                     ../Middlewares/Third_Party/LwIP/system;                     ../Middlewares/Third_Party/LwIP/src/include;                     ../Middlewares/Third_Party/LwIP/src/include/ipv4;                     ../Middlewares/Third_Party/LwIP/system/arch;                     ../Middlewares/Third_Party/LwIP/src/include/ipv4/lwip;                     ../Middlewares/Third_Party/LwIP/src/include/lwip;                     ../Middlewares/Third_Party/LwIP/src/include/netif;                     ../Middlewares/Third_Party/LwIP/src/include/posix;                     ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                     ../Middlewares/Third_Party/LwIP/src/netif/ppp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: dma2d.c stm32f4xx_it.c stm32f4xx_hal_msp.c usart.c ltdc.c gpio.c main.c fmc.c dma.c ethernetif.c lwip.c udp_echoclient.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dsi.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c
  group BSP
    ../BSP/: stm324x9i_lcd.c stm324x9i_sdram.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/snmp/: asn1_enc.c msg_out.c asn1_dec.c mib2.c msg_in.c mib_structs.c
    ../Middlewares/Third_Party/LwIP/src/core/: sys.c memp.c tcp.c init.c dns.c netif.c def.c tcp_in.c stats.c mem.c pbuf.c dhcp.c raw.c tcp_out.c udp.c lwip_timers.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip_frag.c inet.c autoip.c ip.c inet_chksum.c igmp.c ip_addr.c icmp.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c netbuf.c err.c tcpip.c sockets.c netifapi.c api_msg.c netdb.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: chpms.c ppp_oe.c auth.c md5.c lcp.c vj.c ipcp.c ppp.c magic.c pap.c chap.c randm.c fsm.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
software components: CMSIS:CORE 4.1.0
