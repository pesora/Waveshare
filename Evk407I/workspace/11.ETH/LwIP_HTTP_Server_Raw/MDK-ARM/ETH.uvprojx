# Keil uVision project ETH.uvprojx, settings and files
target ETH (ARM-ADS)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ETH +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include;../Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c dhcp.c autoip.c ip4_addr.c ip_frag.c igmp.c icmp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: multilink.c pppos.c chap-new.c pppoe.c fsm.c ipcp.c upap.c magic.c chap_ms.c chap-md5.c pppcrypt.c eui64.c ecp.c utils.c lcp.c ppp.c pppol2tp.c ipv6cp.c mppe.c auth.c demand.c ccp.c vj.c eap.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md4.c des.c sha1.c arc4.c md5.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c def.c pbuf.c udp.c inet_chksum.c sys.c lwip_timers.c memp.c tcp.c stats.c tcp_out.c raw.c mem.c dns.c netif.c init.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c netbuf.c tcpip.c api_lib.c netifapi.c sockets.c pppapi.c netdb.c api_msg.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: icmp6.c ip6_addr.c mld6.c ip6_frag.c ethip6.c ip6.c inet6.c nd6.c dhcp6.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c lwip.c stm32f4xx_it.c ethernetif.c gpio.c usart.c
    ../Application/: app_ethernet.c fs.c httpd.c httpd_cgi_ssi.c
software components: CMSIS:CORE 4.1.0
